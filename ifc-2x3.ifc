Properties of the parts of a building model (IFC2X3)

# File
Description: Fußbodentemperaturregler mit Fernfühler, UP, 10…50 °C, alre-Rahmen, Abdeckung 50 x 50 mm, reinweiß, glänzend, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UN030109, Fußbodentemperaturregler mit Fernfühler, UP, 10…50 °C, alre-Rahmen, Abdeckung 50 x 50 mm, reinweiß, glänzend
In: Raum
Description: Dieser elektronische Zweipunktregler wurde speziell zur Regelung elektrischer (max. 3680 W) oder Warmwasser-Heizungen/Zusatzheizungen für Fußböden und anderer Oberflächentemperiersysteme entwickelt. Fernfühler HF-8/4-K2 (4 m) im Lieferumfang enthalten. Bei Fühlerbruch- und -kurzschluss wird die Heizung abgeschaltet. Über den Eingang Temperaturabsenkung kann auf eine ca. 5 K geringere Temperatur geregelt werden (Nachtabsenkung).; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UN030109; ModelLabel: FETR 101.715#21; GlobalTradeItemNumber: 4050528061379; ProductURL: https://alre.de/produkt_UN030109
Pset_Specification - NominalLength: 0.085 m; NominalWidth: 0.081 m; NominalDepth: 0.0425 m; NetWeight: 0.253
Pset_ALRE_ETIM_Properties - Montageart: Unterputz; Farbe: weiß; Breite: 81; Höhe: 85; Tiefe: 42.5; RAL-Nummer: 9010; Anschluss: sonstige; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Schließer (NO); Messbereich: 10; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Verdeckte Bedienung: no; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 0; Temperatur ablesbar: no; Max. Kontaktbelastung: 16; Differenzwert: 0.5; Sensor extern: yes; Thermische Rückkopplung: ohne; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: no; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UN030109.pdf
